Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2x3 Coordination View
File name: D:\Users\Jonas\Documents\Cadfocus\Ostnor\Projekt\20140428_CAD-objekt_Siljan-Fryken\Arbetsmapp\dusch\83930000\AutoCAD Architecture\83930000.ifc
Time: 2014-05-15T14:11:53
Author: - -
Organization: Ostnor AB
Written by: Eurostep IFC Toolbox - 1.0
Made in: AutoCAD Architecture 2009 Build 5.7.68.0

# IfcProject, 83930000
LongName: 83930000
PSET_ACA_DISPLAY_SET - ACA_DISPLAY_CONFIG_ON_EXPORT: 02 - Normal detaljering; ACA_DISPLAY_SET_ON_EXPORT: 3D Normal

# IfcBuilding, 83930000
ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm

# IfcBuildingElementProxy: 83930000, BUILDINGELEMENTPROXY(1)
In: 83930000
Description: FM Mattsson Siljan Shower kit Mixer and Headshower 160 c/c
